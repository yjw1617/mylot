# Keil uVision project mylot.uvprojx, settings and files
target mylot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: mylot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc;                               ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                               ../Middlewares/Third_Party/FreeRTOS/Source/include;                               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                               ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                               ../Drivers/CMSIS/Include;                               ../Middlewares/Third_Party/STemWin/src;                               ../Middlewares/Third_Party/STemWin/inc;                               ../Middlewares/Third_Party/STemWin/OS;                               ../Middlewares/Third_Party/STemWin/Config;                               ../HARDWARE/inc;                               ../SYSTEM/inc
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c crc.c dma.c fsmc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group App/communication
    ../Core/Src/: message.c
    ../Core/Inc/: message.h
  group App/utils
    ../Core/Inc/: utils.h
    ../Core/Src/: utils.c
  group App/dev/driver
    ../Core/Inc/: leinuo_driver.h mygui_driver.h mytestprotocol_driver.h uart_driver.h
    ../Core/Src/: leinuo_driver.c mygui_driver.c mytestprotocol_diver.c uart_driver.c
  group App/common
    ../Core/Inc/: common_task.h common_dev.h common_timer.h common_event.h
    ../Core/Src/: common_task.c common_dev.c common_timer.c common_event.c
  group Middlewares/STemwin
    ../Middlewares/Third_Party/STemWin/OS/: GUI_X_OS.c
    ../Middlewares/Third_Party/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../Middlewares/Third_Party/STemWin/Lib/: STemWin_CM4_OS_wc16_ot.a
    ../Middlewares/Third_Party/STemWin/src/: GUI_X_Touch_Analog.c
  group App/system
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: mySys.c
    ../SYSTEM/usart/: myUsart.c
  group App/hardware
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/LCD/: myLcd.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
  group App/mygui
    ../Core/Src/: mygui_api.c
    ../Core/Inc/: mygui_api.h
    ../Middlewares/Third_Party/STemWin/Application/: mygui_AlarmDLG.c mygui_FanDLG.c mygui_HumDLG.c mygui_LedDLG.c mygui_LightDLG.c mygui_MainDLG.c mygui_TempDLG.c
  group App/font
    ../Middlewares/Third_Party/STemWin/Application/font/: font.c
  group App/image
    ../Middlewares/Third_Party/STemWin/Application/image/main/: MainAlarm.c MainFan.c MainHum.c MainLed.c MainLight.c MainTemp.c
    ../Middlewares/Third_Party/STemWin/Application/image/sub/: SubAlarmClose.c SubAlarmOpen.c SubFanClose.c SubFanOpen.c SubHome.c SubHum.c SubLedClose.c SubLedOpen.c SubLight.c SubTemp.c
  group App/dev/handle
    ../Core/Src/: dev_handle.c gui_poll_handle.c message_handle.c dev_urgent_handle.c
    ../Core/Inc/: dev_handle.h gui_poll_handle.h message_handle.h dev_urgent_handle.h
  group App
    ../Core/Inc/: wifi_app.h
    ../Core/Src/: wifi_app.c
software components: CMSIS:CORE 5.4.0
